Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:19:38+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-212-001
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Комплекс игровой детский, ZSK-212-001 Игровой комплекс «Паровоз»
In: Площадка
Description: Комплекс игровой детский. Игровой комплекс «Паровоз»; Classification: 59.1.15.01-0532 Комплекс игровой (Классификатор строительных ресурсов (КСР)); Material: Нержавеющая сталь, атмосферостойкий HDPE, армированные канат
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-212-001; ModelReference: Игровой комплекс «Паровоз»; ProductionYear: 2026; ArticleNumber: ZSK-212-001
ORION_Изделие - Артикул: ZSK-212-001; Артикул прежний: SD-212-001; Наименование: Игровой комплекс «Паровоз»; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 6.4 x 10.7 м; Зона безопасности: 9.80 x 14.10 м; Высота свободного падения: 1.8 м; Возраст: для детей от 2 до 12 лет; Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; Цена: 1 100 000 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/play-complexes/355; Код КСИ: CPr>EDB080; Класс КСИ: Комплекс игровой; Коды КСР: 59.1.15.01-0532 … 59.1.15.01-0595
ADSK - ADSK_Наименование: Игровой комплекс «Паровоз»; ADSK_Марка: ZSK-212-001; ADSK_Код изделия: 59.1.15.01-0532; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Нержавеющая сталь, атмосферостойкий HDPE, армированные канаты; ADSK_URL страницы изделия: https://зск.рф/catalog/play-complexes/355
ZSK_Благоустройство - ZSK_Возрастная_группа: для детей от 2 до 12 лет; ZSK_Зона_безопасности: 9.80 x 14.10 м; ZSK_Высота_свободного_падения: 1.8 м; ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDB080; ZSK_Артикул_прежний: SD-212-001
Qto_ORION - Длина: 6400 mm; Ширина: 10700 mm; Высота: 0 mm
